# IAR project libam_hal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: iar; AM_DEBUG_ASSERT; AM_PART_APOLLO
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\apollo; ..\..\..\..\utils
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  group (top)
    ../: am_hal_adc.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
