# Keil uVision project libam_hal.uvprojx, settings and files
target libam_hal (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Apollo_512_BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.9.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libam_hal (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_DEBUG_ASSERT AM_PART_APOLLO keil
  c include: ../../../../mcu/apollo;../../../../utils
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  group source_files
    ../: am_hal_adc.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
