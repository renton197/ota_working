# Keil uVision project exactle_fit_amota_multi_boot.uvprojx, settings and files
target exactle_fit_amota_multi_boot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Apollo_512_BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.9.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exactle_fit_amota_multi_boot
  AfterMake: fromelf --bin --output bin\exactle_fit_amota_multi_boot.bin bin\exactle_fit_amota_multi_boot.axf
  AfterMake: fromelf -cedrst --output bin\exactle_fit_amota_multi_boot.txt bin\exactle_fit_amota_multi_boot.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO AM_PART_APOLLO keil
  c include: ../src;../../../bsp;../../../../../utils;../../../../../devices;../../../../../bootloader;../../../../../mcu/apollo
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\exactle_fit_amota_multi_boot.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: exactle_fit_amota_multi_boot.c image_boot_handlers.c ios_boot_handlers.c uart_boot_handlers.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_spiflash.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
