# Keil uVision project exactle_fit_amota.uvprojx, settings and files
target exactle_fit_amota (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Apollo_512_BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.9.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exactle_fit_amota
  AfterMake: fromelf --bin --output bin\exactle_fit_amota.bin bin\exactle_fit_amota.axf
  AfterMake: fromelf -cedrst --output bin\exactle_fit_amota.txt bin\exactle_fit_amota.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA HCI_TR_UART WSF_TRACE_ENABLED AM_DEBUG_PRINTF __BATCH_ERASE_INTERNAL__ AM_PART_APOLLO keil
  c include: ../../../../../boards/apollo_evk_btle/examples/exactle_fit_amota_multi_boot/src;../../../../../bootloader;../../../../../devices;../../../../../mcu/apollo;../../../../../third_party/exactle/apollo-host/projects/common;../../../../../third_party/exactle/sw/apps/app;../../../../../third_party/exactle/sw/apps/app/include;../../../../../third_party/exactle/sw/apps/fit_ota;../../../../../third_party/exactle/sw/hci/ambiq;../../../../../third_party/exactle/sw/hci/include;../../../../../third_party/exactle/sw/profiles/amota;../../../../../third_party/exactle/sw/profiles/bas;../../../../../third_party/exactle/sw/profiles/hrps;../../../../../third_party/exactle/sw/profiles/rscp;../../../../../third_party/exactle/sw/profiles/uribeacon;../../../../../third_party/exactle/sw/sec/common;../../../../../third_party/exactle/sw/sec/include;../../../../../third_party/exactle/sw/services;../../../../../third_party/exactle/sw/stack/cfg;../../../../../third_party/exactle/sw/stack/hci;../../../../../third_party/exactle/sw/stack/include;../../../../../third_party/exactle/ws-core/include;../../../../../third_party/exactle/ws-core/sw/util;../../../../../third_party/exactle/ws-core/sw/wsf/ambiq;../../../../../third_party/exactle/ws-core/sw/wsf/include;../../../../../utils;../../../bsp;../src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\exactle_fit_amota.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group bootloader
    ../../../../../bootloader/: am_bootloader.c
  group app
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
  group generic
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
  group fit_ota
    ../../../../../third_party/exactle/sw/apps/fit_ota/: fit_ota_main.c
  group ambiq
    ../../../../../third_party/exactle/sw/hci/ambiq/: da14581_hci_image.c hci_cmd.c hci_core.c hci_core_ps.c hci_drv.c hci_evt.c hci_tr.c hci_vs.c
  group amota
    ../../../../../third_party/exactle/sw/profiles/amota/: amotas_main.c
  group bas
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
  group hrps
    ../../../../../third_party/exactle/sw/profiles/hrps/: hrps_main.c
  group rscp
    ../../../../../third_party/exactle/sw/profiles/rscp/: rscps_main.c
  group common
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
  group services
    ../../../../../third_party/exactle/sw/services/: svc_amotas.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hidg.c svc_hidkb.c svc_hidm.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group cfg
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
  group hci
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
  group util
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c wstr.c
  group ambiq
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
  group common
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_msg.c wsf_queue.c wsf_timer.c
  group src
    ../src/: binary_counter.c exactle_fit_amota.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_adxl362.c am_devices_da14581.c am_devices_led.c am_devices_spiflash.c
  group src
    ../../../../../boards/apollo_evk_btle/examples/exactle_fit_amota_multi_boot/src/: image_boot_handlers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../third_party/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
