# Keil uVision project exactle_fit.uvprojx, settings and files
target exactle_fit (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.8.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exactle_fit_amota
  AfterMake: fromelf --bin --output bin\exactle_fit_amota.bin bin\exactle_fit_amota.axf
  AfterMake: fromelf -cedrst --output bin\exactle_fit_amota.txt bin\exactle_fit_amota.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA HCI_TR_UART AM_PART_APOLLO keil
  c include: ../../../../../devices;../../../../../mcu/apollo;../../../../../third_party/exactle/sw/apps/app;../../../../../third_party/exactle/sw/apps/app/include;../../../../../third_party/exactle/sw/apps/fit_ota;../../../../../third_party/exactle/sw/hci/ambiq;../../../../../third_party/exactle/sw/hci/include;../../../../../third_party/exactle/sw/profiles/bas;../../../../../third_party/exactle/sw/profiles/hrps;../../../../../third_party/exactle/sw/services;../../../../../third_party/exactle/sw/stack/cfg;../../../../../third_party/exactle/sw/stack/hci;../../../../../third_party/exactle/sw/stack/include;../../../../../third_party/exactle/sw/util;../../../../../third_party/exactle/sw/wsf/ambiq;../../../../../third_party/exactle/sw/wsf/include;../../../../../utils;../../../bsp;../src;../../../../../third_party/exactle/sw/profiles/amota;..\..\..\..\..\bootloader;..\..\..\..\apollo_evk_base\examples\multi_boot\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\exactle_fit.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group app
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_server.c app_slave.c
  group generic
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
  group fit
    ../../../../../third_party/exactle/sw/apps/fit_ota/: fit_ota_main.c
  group ambiq
    ../../../../../third_party/exactle/sw/hci/ambiq/: da14581_hci_image.c hci_cmd.c hci_core.c hci_core_ps.c hci_drv.c hci_evt.c hci_tr.c hci_vs.c
  group bas
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
  group hrps
    ../../../../../third_party/exactle/sw/profiles/hrps/: hrps_main.c
  group services
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_dis.c svc_gls.c svc_hidg.c svc_hidkb.c svc_hidm.c svc_hrs.c svc_hts.c svc_px.c svc_wp.c svc_wss.c svc_amotas.c
  group cfg
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
  group hci
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
  group util
    ../../../../../third_party/exactle/sw/util/: bda.c bstream.c calc128.c crc32.c wstr.c
  group ambiq
    ../../../../../third_party/exactle/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
  group common
    ../../../../../third_party/exactle/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_sec.c wsf_sec_aes.c wsf_sec_cmac.c wsf_sec_ecc_debug.c wsf_timer.c
  group src
    ../src/: exactle_fit_amota.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_debug.c
  group devices
    ../../../../../devices/: am_devices_adxl362.c am_devices_da14581.c am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../third_party/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
  group amota
    ../../../../../third_party/exactle/sw/profiles/amota/: amotas_main.c
  group multiboot
    ../../../../apollo_evk_base/examples/multi_boot/src/: image_boot_handlers.c
    ../../../../../bootloader/: am_bootloader.c
